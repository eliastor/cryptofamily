# IAR project crypto.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: SINGLE_THREADED; NO_DEV_RANDOM; HAVE_ED25519; NO_MD5; NO_SHA; WOLFSSL_SHA512; __CORTEX_M3__; NO_DEV_RANDOM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: crypto.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: EC.c EC.h keccak.c keccak.h LFSR86540.c LFSR86540.h littlemorelongint.h main.c primes.c sponge.c sponge.h stretchint.c stretchint.h
  group 25519
    25519/: c25519.c c25519.h ed25519.c ed25519.h edsign.c edsign.h f25519.c f25519.h fprime.c fprime.h morph25519.c morph25519.h sha512.c sha512.h
  group field
    field/: t0r_f25519.c
  group helper
    helper/: binary.c memtools.c memtools.h
  group macros
    macros/: concat.h min_max.h module.h
  group wolf25519
    wolf25519/: compress.c compress.h curve25519.c curve25519.h dh.c dh.h ecc_fp.c ed25519.c ed25519.h error-crypt.h fe_low_mem.c fe_operations.c fe_operations.h ge_low_mem.c ge_operations.c ge_operations.h hash.h integer.c integer.h logging.c logging.h memory.c memory.h misc.c misc.h mpi_class.h mpi_superclass.h random.c random.h settings.h sha.c sha.h sha256.c sha256.h sha512.c sha512.h types.h visibility.h wc_port.h
